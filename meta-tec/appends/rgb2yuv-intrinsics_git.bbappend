inherit externalsrc
EXTERNALSRC = "/home/jo/meta-tec/meta-tec/sources/rgb2yuv-intrinsics"
EXTERNALSRC_BUILD = "/home/jo/meta-tec/meta-tec/sources/rgb2yuv-intrinsics"

# initial_rev: 17a25e485cd3eb1a681305d2f808a50b4f56e9fb
