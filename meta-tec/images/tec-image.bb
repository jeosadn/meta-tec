SUMMARY = "A console development image with some C/C++ dev tools, and image conversion"

inherit /home/jo/rendimiento/g6_hpes_2019/assignment1/poky/meta-rpi/images/console-image.bb

export IMAGE_BASENAME = "tec-image"
