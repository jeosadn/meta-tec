inherit externalsrc
EXTERNALSRC = "/home/jo/meta-tec/rgb2yuv-c"
EXTERNALSRC_BUILD = "/home/jo/meta-tec/rgb2yuv-c"

# initial_rev: e871f257a0986abc097137b63e064f02b778257f
