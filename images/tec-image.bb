SUMMARY = "A console development image with some C/C++ dev tools, and image conversion"

inherit ../meta-rpi/images/console-image.bb

export IMAGE_BASENAME = "tec-image"
